# Keil uVision project CTWing_Skit_BC28.uvprojx, settings and files
target Ctwing_SKIT_BC28 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ctwing_SKIT_BC28 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\rt-thread\include\libc;..\rt-thread\include;..\rt-thread\components\finsh;..\bsp;..\rt-thread\components\ringbuff;..\rt-thread\components;..\com;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c i2c.c
    ../bsp/: board.c
    ../user/: bc28_thread.c user_main.c iot_thread.c AepServiceCodes.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group RT-Thread
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group finsh
    ../rt-thread/components/finsh/: cmd.c msh.c shell.c
  group components
    ../rt-thread/components/ringbuff/: ringbuffer.c
  group com
    ../com/: com.c
  group Application/UserDriver
    ../bsp/: HTS221.c
software components: CMSIS:CORE 4.3.0
